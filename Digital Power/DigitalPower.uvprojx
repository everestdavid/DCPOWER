# Keil uVision project DigitalPower.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.5.0
  cpu: IROM(0x00000000,0x00008000) IRAM(0x10000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DigitalPower +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: digitalpower.c
  group Board
    ./: DigitalPower_LPC824-LPCXpresso.c utilities.c Serial.c SPI0.c Keil_Retarget.c adc.c i2c.c
software components: CMSIS:RTOS:Keil RTX 4.80.0, Device:Startup 1.0.0
